# Keil uVision project cst148_tester.uvproj, settings and files
target cst148_tester (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cst148_tester +hex
  AfterMake: C:/Keil/ARM/BIN40/fromelf.exe --bin -o ./keil_output/cst148_tester.bin ./keil_output/cst148_tester.axf
  c flags: Optim=1
  c include: .\hyn_public_inc;.\hyn_public_src;.\hyn_controler_lib;
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x1400
  group public_inc
    ./hyn_public_inc/: all_includes.h base_define.h cst1xx_register.h system_boot.c
  group public_src
    ./hyn_public_src/: main.c tester_def.h tester_fun.c tester_fun.h fwi2c.c css1xxx_code.h
